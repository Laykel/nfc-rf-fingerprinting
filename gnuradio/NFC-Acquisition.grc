options:
  parameters:
    author: luc
    description: The goal is to acquire NFC communications and record them to a file.
    generate_options: qt_gui
    id: nfc_acquisition
    output_language: python
    title: NFC Acquisition
  states: {}

blocks:
- name: boost
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '20'
    value: '1'
    widget: slider
  states: {}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: samp_rate/1000
    step: '1000'
    stop: samp_rate/4
    value: samp_rate/5
  states: {}
- name: filepath
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: File path
    type: string
    value: /dev/null
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 13.56e6
  states: {}
- name: frequency
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 13.56e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    orient: Qt.Horizontal
    start: samp_rate/1000
    step: '1000'
    stop: samp_rate/4
    value: samp_rate/5
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: boost
    type: complex
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"soapy=0,driver=lime"'
    bb_gain0: '16'
    bw0: 2e6
    freq0: frequency
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,0,2,1
    name: '"FFT plot"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,1,2,1
    name: '"Magnitude time plot"'
    size: '262144'
    srate: samp_rate
    type: float
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,2,1
    name: '"I/Q time plot"'
    size: '32768'
    srate: samp_rate
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    gui_hint: 2,0,2,1
    name: '"Waterfall plot"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_const_sink_x_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
