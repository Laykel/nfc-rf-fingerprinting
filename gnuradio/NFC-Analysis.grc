options:
  parameters:
    author: luc
    description: Takes as input a recorded NFC communication and visualizes the signal through different graphs
    generate_options: qt_gui
    id: nfc_analysis
    output_language: python
    title: NFC Analysis
  states: {}

blocks:
- name: boost
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: samp_rate/1000
    step: '1000'
    stop: samp_rate/4
    value: samp_rate/5
  states: {}
- name: filepath
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,1,1,1
    label: File path
    labels: '[]'
    num_opts: '0'
    options: '["/home/luc/HEIG/TB/data/nfc-2.0-2.bin",  "/dev/null", "/home/luc/HEIG/TB/data/nfc-2.0-1.bin"]'
    type: string
    value: ''
  states: {state: disabled}
- name: filepath
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,1,1,1
    label: File path
    labels: listdir("/home/luc/HEIG/TB/data")
    num_opts: '0'
    options: '[path.abspath(x) for x in listdir("/home/luc/HEIG/TB/data")]'
    type: string
    value: '0'
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: 13.56e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    orient: Qt.Horizontal
    start: samp_rate/1000
    step: '1000'
    stop: samp_rate/4
    value: samp_rate/5
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/luc/HEIG/TB/REPO_nfc-rf-fingerprinting/data/archives/taoglas-antenna/3.0-taoglas-1.nfc
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: boost
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from os import listdir, path
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,0,2,1
    name: '"FFT plot"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,2,1
    name: '"I/Q time plot"'
    size: '32768'
    srate: samp_rate
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,1,2,1
    name: '"Magnitude time plot"'
    size: '32768'
    srate: samp_rate
    type: float
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    gui_hint: 2,0,2,1
    name: '"Waterfall plot"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
