options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Center Frequency
    orient: Qt.Horizontal
    start: 80.1e6
    step: '200000'
    stop: 108.1e6
    value: 100.3e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Rx Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    comment: |-
      Adjust this value to set the
      bandwidth of the signal
    value: '5000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: signal_bandwidth
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: signal_bandwidth
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch1: '0'
    gain_dB_ch0: rx_gain
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate
    serial: 1D588EF2B7BCD3
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '7'
    cutoff_freq: samp_rate/2-20000
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_KAISER
  states: {}
- name: note_0
  id: note
  parameters:
    note: group member of pulse, pulse-access, and audio
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.5'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,2,1
    label1: Tx
    showports: 'True'
    type: complex
    units: dBm
    wintype: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
