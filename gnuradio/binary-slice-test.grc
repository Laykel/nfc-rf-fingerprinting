options:
  parameters:
    author: luc
    generate_options: qt_gui
    id: binary_slice_test
    output_language: python
    title: binary-slice-test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.2'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/luc/Desktop/TB-BinarySliced/miller.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/luc/Desktop/TB-BinarySliced/manchester.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/luc/HEIG/TB/REPO_nfc-rf-fingerprinting/data/raw/airspyhf+/test-tag3.nfc
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '4003'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: manchester (all)
    label2: miller
    nconnections: '2'
    size: '8192'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_const_vxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
