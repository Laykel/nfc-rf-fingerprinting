options:
  parameters:
    author: Luc Wachter
    generate_options: qt_gui
    id: binary_slice_test
    output_language: python
    title: Binary slice test
  states: {}

blocks:
- name: manchester_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-300e-3'
    step: '100e-4'
    stop: '100e-3'
    value: '0'
  states: {}
- name: miller_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-300e-3'
    step: '100e-4'
    stop: '100e-3'
    value: '-100e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: miller_offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: manchester_offset
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/luc/HEIG/TB/REPO_nfc-rf-fingerprinting/data/archives/cut-signals/test-grc.nfc
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/luc/Desktop/TB-BinarySliced/manchester.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/luc/HEIG/TB/REPO_nfc-rf-fingerprinting/data/dataset/1/tag5-1.nfc
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: manchester (all)
    label2: miller
    nconnections: '2'
    size: '120000'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_const_vxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
