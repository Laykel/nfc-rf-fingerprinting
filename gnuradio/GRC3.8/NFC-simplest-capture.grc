options:
  parameters:
    author: Luc Wachter
    generate_options: qt_gui
    id: simplest_capture
    output_language: python
    title: Simplest Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/luc/HEIG/TB/test.bin
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '16'
    freq0: 13.56e6
    gain0: '16'
    gain_mode0: 'True'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
